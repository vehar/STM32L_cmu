# Keil uVision project 1.uvproj, settings and files
target Target STM (ARM-ADS)
  device: STM32L152R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1 +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c include: .\lib\cmsis;.\lib\spl;..\1;.\lib\spl\inc;.\lib\spl\src;.\lib\i2c;.\lib\ina219;.\lib\ds3231;.\lib\taskmgr;.\lib\spi;.\lib\uart;.\lib\gps;.\lib\adc;.\lib\btns;.\lib\timer;.\lib\Communication;..\STM_RDM_11v3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./: startup_stm32l1xx_md.s
  group cmsis
    ./lib/cmsis/: system_stm32l1xx.c stm32l1xx.h
  group spl
    ./lib/spl/: stm32l1xx_conf.h
    ./lib/spl/inc/: stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_rcc.h stm32l1xx_spi.h stm32l1xx_adc.h stm32l1xx_dma.h stm32l1xx_exti.h misc.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_pwr.h
    ./lib/spl/src/: stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_adc.c stm32l1xx_dma.c stm32l1xx_exti.c misc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_dbgmcu.c
  group source
    ./: main.h main.cpp
  group user
    ./lib/i2c/: i2c_hard_stm32l1.h i2c_hard_stm32l1.c
    ./lib/ina219/: ina219.c ina219.h
    ./lib/ds3231/: ds3231.c ds3231.h
    ./lib/spi/: spi.c spi.h
    ./lib/taskmgr/: taskmgr.c taskmgr.h
    ./lib/uart/: uart.c uart.h
    ./lib/gps/: gps.c gps.h
    ./lib/adc/: adc.c adc.h
    ./lib/btns/: btns.c btns.h
    ./lib/timer/: timer.c timer.h
    ./lib/Communication/: Communication_DM_STM.cpp
    ./lib/spl/src/: stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c
    ./: math_helpers.c board_helpers.c temperature_measurement.c
